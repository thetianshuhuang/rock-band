# Keil uVision project rock-band.uvproj, settings and files
target main (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: rock-band
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s main.c tm4c123gh6pm.h PLL.c PLL.h
  group Network
    ./network/: network.h fifo.c fifo.h network.c uart.c uart.h c_client.c c_client.h
  group Audio
    ./audio/: dac.c dac.h driver.c driver.h
  group Controller
    ./controller/: controller.c controller.h dsp.c dsp.h
  group Game
    ./game/: core.h core.c
  group Display
    ./display/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h ST7735.c ST7735.h guitar.c guitar.h splash.c splash.h
  group Menu
    ./menu/: menu.h menu.c menu_defs.c menu_defs.h
